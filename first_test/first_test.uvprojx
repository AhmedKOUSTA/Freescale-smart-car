# Keil uVision project first_test.uvprojx, settings and files
target first_test (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: first_test
  c flags: Optim=2 uC99=1
  c misc: -DDEVICE_PORTOUT=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_KL25Z --preinclude=mbed_config.h -D__CORTEX_M0PLUS -DDEVICE_SEMIHOST=1 -D__ASSERT_MSG -DMBED_BUILD_TIMESTAMP=1475259844.07 --no_rtti -DDEVICE_SLEEP=1 --split_sections -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -O3 -DDEVICE_SPISLAVE=1 -DTARGET_KLXX -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_CORTEX_M0 -DDEVICE_ANALOGIN=1 -DTARGET_RELEASE -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DARM_MATH_CM0PLUS -Ospace -DTARGET_Freescale -DDEVICE_I2C=1 -DDEVICE_PORTIN=1 -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_M0P -DDEVICE_SERIAL=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS --cpu=Cortex-M0 -D__MBED_CMSIS_RTOS_CM
  c include: .; mbed/.; mbed/TARGET_KL25Z; mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-DARM_MATH_CM0PLUS,-D__CORTEX_M0PLUS,-D__MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/MKL25Z4.sct
  group TARGET_KL25Z
    mbed/TARGET_KL25Z/: cmsis.h cmsis_nvic.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h device.h gpio_object.h MKL25Z4.h objects.h PeripheralNames.h PinNames.h PortNames.h system_MKL25Z4.h
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/: cmsis_nvic.o mbed.ar retarget.o startup_MKL25Z4.o sys.o system_MKL25Z4.o
  group first_test
    ./: Direction.h main.cpp mbed_config.h TFC.cpp TFC.h
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h error.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h mbed.h mbed_debug.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h us_ticker_api.h wait_api.h
